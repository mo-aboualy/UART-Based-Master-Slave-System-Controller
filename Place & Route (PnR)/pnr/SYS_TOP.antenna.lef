

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SYS_TOP 
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.583 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.80423 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.288 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.38768 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.55557 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 2.75522 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 0.369 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.77489 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.698 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.35978 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 12.44 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 60.0288 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1599 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 143.083 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 693.187 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.25766 LAYER VIA45 ;
  END scan_rst
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 8.437 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 40.582 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 7.113 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.7907 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.2259 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 36.0665 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 173.274 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.656083 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.926 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.6965 LAYER METAL4 ;
    ANTENNAGATEAREA 2.0449 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 38.9645 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 187.307 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.656083 LAYER VIA45 ;
  END test_mode
  PIN SE 
    ANTENNAPARTIALMETALAREA 1.877 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.02837 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.534 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.1909 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.214 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.22414 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 49.9437 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 251.202 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 5.41839 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 9.994 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 48.2635 LAYER METAL5 ;
    ANTENNAGATEAREA 0.2132 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 155.297 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 752.237 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 5.41839 LAYER VIA56 ;
  END SE
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 7.375 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.4738 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 7.133 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.5021 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.573 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.94853 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 1.3278 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 5.57479 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNAPARTIALMETALAREA 40.152 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 235.825 LAYER METAL7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 1137.53 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 6271.1 LAYER METAL7 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 0.652 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.13612 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 19.611 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 94.5213 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 10.823 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 52.251 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 220.481 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 1077.91 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 4.74109 LAYER VIA67 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 2.883 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8672 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 23.884 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 115.074 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.493 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.6137 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 120.763 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 591.046 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA45 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 2.523 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1356 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 33.56 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 161.616 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 10.964 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 52.9292 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 252.86 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1222.52 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA45 ;
  END SI[0]
  PIN SO[3] 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.069 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.95189 LAYER METAL3 ;
  END SO[3]
  PIN SO[2] 
    ANTENNAPARTIALMETALAREA 4.25 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.4425 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 24.517 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 118.119 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 489.982 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2365.47 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END SO[2]
  PIN SO[1] 
    ANTENNAPARTIALMETALAREA 2.703 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0014 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.537 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 2.965 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4541 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 93.3413 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 451.028 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.38846 LAYER VIA45 ;
  END SO[1]
  PIN SO[0] 
    ANTENNAPARTIALMETALAREA 3.399 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.5416 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 13.778 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 66.8494 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.247 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 508.208 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 2452.44 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 3.87635 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.974 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.87734 LAYER METAL5 ;
    ANTENNAGATEAREA 0.247 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 512.152 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2472.19 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAMAXCUTCAR 4.16866 LAYER VIA56 ;
    ANTENNADIFFAREA 0.6 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 2.787 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5979 LAYER METAL6 ;
    ANTENNAGATEAREA 0.3133 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 521.047 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 2515.59 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 4.16866 LAYER VIA67 ;
  END SO[0]
  PIN RST_N 
    ANTENNAPARTIALMETALAREA 1.011 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.86291 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.534 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.57094 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 2.108 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3319 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 1.37 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.7821 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 205.929 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1001.49 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA56 ;
  END RST_N
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.323 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.55363 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.37 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.7821 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.468 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.44348 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 2.09893 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 10.2416 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.619 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.97739 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.108 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3319 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.823299 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 4.043 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END REF_CLK
  PIN UART_RX_IN 
    ANTENNAPARTIALMETALAREA 5.517 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 26.5368 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 8.385 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 40.7167 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3328 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 27.7022 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 134.13 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.783666 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.156 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.9928 LAYER METAL4 ;
    ANTENNAGATEAREA 0.3328 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 43.195 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 209.229 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.00061 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 13.379 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 64.5454 LAYER METAL5 ;
    ANTENNAGATEAREA 0.6981 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 62.3598 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 301.688 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.00061 LAYER VIA56 ;
  END UART_RX_IN
  PIN UART_TX_O 
    ANTENNAPARTIALMETALAREA 8.059 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 38.7638 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.409 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.15969 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.571 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 5.68 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 27.5132 LAYER METAL5 ;
  END UART_TX_O
  PIN parity_error 
    ANTENNAPARTIALMETALAREA 0.807 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.88167 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 30.425 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 146.729 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3653 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 99.6914 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 481.47 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAMAXCUTCAR 0.945647 LAYER VIA56 ;
    ANTENNADIFFAREA 0.6 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 6.208 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 30.0529 LAYER METAL6 ;
    ANTENNAGATEAREA 0.4186 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 155.499 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 762.199 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 5.41839 LAYER VIA67 ;
  END parity_error
  PIN framing_error 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.627 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.82587 LAYER METAL3 ;
  END framing_error
END SYS_TOP

END LIBRARY
